# Keil uVision project pixyflash.uvproj, settings and files
target pixyflash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: pixyflash +hex
  AfterMake: fromelf --bin -o "@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: CORE_M4 PIXY
  c include: ., ..\libpixy_m4\inc, ..\common\inc, ..\..\common\inc
  scatter file: ram.sct
  group source
    ./: main.cpp lpc43xx_rgu.c flashprog.cpp
  group libs
    ../libpixy_m4/: libpixy_m4.lib
