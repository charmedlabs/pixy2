# Keil uVision project main_m4.uvprojx, settings and files
target Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: pixy_firmware +hex
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: CORE_M4 IPC_MASTER PIXY KEIL
  c include: ., inc, ..\libpixy_m4\inc, ..\..\common\inc, ..\common\inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\spifi.sct
  group Source Code
    ./src/: analogdig.cpp button.cpp conncomp.cpp exec.cpp i2c.cpp progblobs.cpp progvideo.cpp serial.cpp spi.cpp uart.cpp main_m4.cpp cr_start_m0.c fpu_init.c platform_config.c usbcore.c usbdesc.c usbhw.c usbuser.c camera.cpp flash.cpp led.cpp misc.cpp param.cpp pixy_init.cpp power.cpp sccb.cpp smlink.cpp usblink.cpp startup_LPC43xx_m4.s spifilib_dev_common.c spifilib_fam_standard_cmd.c progpt.cpp rcservo.cpp lpc43xx_timer.c progline.cpp line.cpp equeue.cpp spi2.cpp
    ../../common/src/: blob.cpp blobs.cpp calc.cpp chirp.cpp colorlut.cpp qqueue.cpp
    ../common/src/: debug_frmwrk.c ipc_mbx.c lpc43xx_adc.c lpc43xx_cgu.c lpc43xx_i2c.c lpc43xx_scu.c lpc43xx_ssp.c lpc43xx_uart.c system_LPC43xx.c
target RAM (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.0
  cpu: as above
  output: main_m4 +hex
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: CORE_M4 IPC_MASTER PIXY KEIL
  c include: ., inc, ..\libpixy_m4\inc, ..\..\common\inc, ..\common\inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\ram.sct
software components: CMSIS:CORE 5.0.0
